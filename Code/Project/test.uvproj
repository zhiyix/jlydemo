# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1 OneElfS=1
  c define: STM32L1XX_HD,USE_STDPERIPH_DRIVER,USE_HAL_DRIVER,STM32L152xE,MB_SLAVE
  c include: ..\Libraries\CMSIC\startup;..\Libraries\CMSIC;..\Libraries\inc;..\Libraries\src;..\Doc;..\User;..\User\init;..\User\SysTick;..\User\peripherals\inc;..\User\peripherals\src;..\Libraries;..\User\logical-layer;..\BTBusLibraries\FreeModbus\modbus;..\BTBusLibraries\HAL_Drivers\STM32L1xx_HAL_Driver\Inc;..\BTBusLibraries\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIC/startup/: startup_stm32l1xx_hd.s
  group CMSIC
    ../Libraries/CMSIC/: system_stm32l1xx.h core_cm3.c core_cm3.h stm32l1xx.h system_stm32l1xx.c
  group FWLIB
    ../Libraries/src/: stm32l1xx_usart.c misc.c stm32l1xx_adc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_tim.c stm32l1xx_syscfg.c stm32l1xx_spi.c
  group BTBUS
    ../BTBusLibraries/MDK-ARM/STM32L152_EVAL/: BTBUS_Library.lib
    ../BTBusLibraries/Src/: stm32l1xx_hal_msp.c freemodbus.c
  group USER
    ../User/: main.c main.h stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h global.c
    ../User/init/: bsp_init.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/peripherals/src/: bsp_adc.c bsp_exti_key.c bsp_lcd.c bsp_usart.c bsp_spi_flash.c bsp_i2c.c bsp_timer.c bsp_rtc.c
    ../User/logical-layer/: bsp_class.c bsp_datadeal.c bsp_alarmdeal.c bsp_powerdeal.c bsp_sensordeal.c bsp_serialdeal.c bsp_bootstop.c bsp_storagedata.c
  group DOC
    ../Doc/: readme.txt note.txt
