# Keil uVision project Library.uvproj, settings and files
target STM32L152D_EVAL (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152D_EVAL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L152xD,USE_HAL_DRIVER,USE_STM32L152D_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L152D_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L1xx_HAL_Driver
    ../HAL_Drivers//STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c
    ../HAL_Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_uart.c
  group Example/User
    ../Src/: main.c mcu_itm.c mcu_tim.c stm32l1xx_hal_msp.c stm32l1xx_it.c freemodbus.c
  group ModBus/port
    ../mbport/: port.c portevent.c portserial.c porttimer.c
  group FreeModBus/src
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/: mb.c
target STM32L152_EVAL (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BTBUS_Library (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L152xB,USE_HAL_DRIVER,MB_SLAVE,
  c include: ..\Inc;..\HAL_Drivers\STM32L1xx_HAL_Driver\Inc;..\FreeModbus\modbus;..\HAL_Drivers\CMSIS\Device\ST\STM32L1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
